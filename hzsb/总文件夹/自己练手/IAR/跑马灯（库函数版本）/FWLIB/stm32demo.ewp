# IAR project stm32demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: inc; ..\CMSIS\Startup; ..\CMSIS\System; ..\User; ..\FWLIB; ..\Utilities\STM32_EVAL; ..\CMSIS\System\delay; ..\CMSIS\System\sys; ..\CMSIS\System\usart; C:\Users\Administrator\Desktop\IAR\IAR-STM32\Project
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: stm32demo.out
  ILINK.IlinkIcfFile: E:\IAR\IAR-STM32\Config\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS/Startup
    $EW_DIR$/IAR-STM32/CMSIS/Startup/: startup_stm32f10x_hd.s
  group CMSIS/System
    ../CMSIS/System/delay/: delay.c
    $EW_DIR$/IAR-STM32/CMSIS/System/: system_stm32f10x.c
  group FWLIB
    src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Project
    ../Project/: led.c
  group User
    $EW_DIR$/IAR-STM32/User/: main.c stm32f10x_it.c
